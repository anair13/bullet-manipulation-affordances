Commit message: env v5

File: roboverse/envs/assets/bullet-objects/wall/wall_narrow_r.urdf (robot description, URDF)
Before this commit: robot bowl.urdf, 2 links, 1 joints
Links:
- link base: geometry collision box size=.01 1 .2; collision box size=1 .01 .2
